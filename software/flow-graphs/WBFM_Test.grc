options:
  parameters:
    author: Lime Microsystems
    category: Custom
    generate_options: no_gui
    id: WBFM_Test
    output_language: python
    title: FM receiver
  states: {}

blocks:
- name: cut_freq
  id: variable
  parameters:
    value: '28000'
  states: {}
- name: freq_value
  id: variable
  parameters:
    value: '94200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: trans_width
  id: variable
  parameters:
    value: '210000'
  states: {}
- name: volume
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_wfm_rcv_0_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: limesdr_source_0_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    gain_dB_ch0: '60'
    gain_dB_ch1: '60'
    lna_path_ch1: '1'
    oversample: '0'
    rf_freq: freq_value
    samp_rate: samp_rate
    serial: 1D588FD736569E
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: '1'
    gain: '1'
    samp_rate: 2e6
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_1_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    fbw: '0.1'
    interp: '48'
    taps: ''
    type: ccc
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [analog_wfm_rcv_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_0, '0']
- [limesdr_source_0_0, '0', low_pass_filter_0_1, '0']
- [low_pass_filter_0_1, '0', rational_resampler_xxx_1_0_1, '0']
- [rational_resampler_xxx_1_0_1, '0', analog_wfm_rcv_0_1, '0']

metadata:
  file_format: 1
