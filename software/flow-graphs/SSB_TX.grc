options:
  parameters:
    generate_options: qt_gui
    id: SSB_TX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: lime_serial
  id: variable
  parameters:
    comment: Find the value for your LimeSDR using LimeUtil --find
    value: '"1D5882F9FB64B6"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: '60'
    oversample: '0'
    rf_freq: '144400000'
    samp_rate: samp_rate
    serial: lime_serial
  states: {}

connections:
- [audio_source_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', limesdr_sink_0, '0']

metadata:
  file_format: 1
