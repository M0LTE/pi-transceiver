options:
  parameters:
    author: Barry Duggan
    description: NB FM receiver
    generate_options: qt_gui
    id: NFM_rcv
    output_language: python
    title: NFM_rcv
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency RB0-RB15
    min_len: '50'
    orient: Qt.Horizontal
    start: '433000000'
    step: '25000'
    stop: '433375000'
    value: '433000000'
    widget: dial
  states: {}
- name: freq_value
  id: variable
  parameters:
    value: '433000000'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    orient: Qt.Horizontal
    start: '-100'
    step: '5'
    stop: '0'
    value: '-60'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1.00'
    value: '0.5'
    widget: slider
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: '5000'
    quad_rate: int(192000)
    tau: '75E-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: '0'
    channel_mode: '0'
    gain_dB_ch0: rf_gain
    oversample: '0'
    rf_freq: freq_value
    samp_rate: samp_rate
    serial: 1D588FD736569E
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '28000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '21000'
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_1_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    fbw: '0.1'
    interp: '48'
    taps: ''
    type: ccc
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [limesdr_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1_0_1, '0']
- [rational_resampler_xxx_1_0_1, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
