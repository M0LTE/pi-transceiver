options:
  parameters:
    generate_options: no_gui
    id: SSB_TX
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: freq_value
  id: variable
  parameters:
    value: '144000000'
  states: {}
- name: lime_serial
  id: variable
  parameters:
    comment: Find the value for your LimeSDR using LimeUtil --find
    value: '"1D588FD736569E"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2800'
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: '60'
    oversample: '0'
    rf_freq: freq_value
    samp_rate: samp_rate
    serial: lime_serial
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [audio_source_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', dc_blocker_xx_1, '0']
- [dc_blocker_xx_1, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', limesdr_sink_0, '0']

metadata:
  file_format: 1
