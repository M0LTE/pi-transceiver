options:
  parameters:
    author: tf
    generate_options: no_gui
    id: audiotest
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}

connections:
- [audio_source_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
